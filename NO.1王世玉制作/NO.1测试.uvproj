# Keil uVision project NO.1测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: NO.1测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 1602.c 4anjian.c timer.c bujindianji.c
  group headfile
    ./: 1602.h laba.h timer.h 4anjian.h bujindianji.h
